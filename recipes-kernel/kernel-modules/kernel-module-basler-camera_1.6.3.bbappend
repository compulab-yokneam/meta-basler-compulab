FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-basler-camera-driver-Fix-Linux-Kernel-6.y-build-issu.patch;patchdir=.."

